# Keil uVision project C8051_Y12_5.uvproj, settings and files
target Target 1 (MCS-51)
  device: C8051F020 Silicon Laboratories, Inc.
  cpu: IRAM(0-0xFF) XRAM(0-0xFFF) IROM(0-0xFFFF) CLOCK(25000000)
  output: C8051_Y12_5 +hex
  c flags: Optimize=7 SizeSpeed=1
  group Source Group 1
    ./: STARTUP.A51
    ./source/: ChargeVolt.c check.C dely.C EnergyControl.C fnJiaoZhun.C IIC.C Initialize.C main.c stepmotor.c UART-RF.C display.C AM2302.C
